# Keil uVision project stm32f1xx_demo.uvprojx, settings and files
target stm32f1xx_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1xx_demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99 --gnu
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\inc;.\FreeRTOSv9.0.0\Source\include;.\FreeRTOSv9.0.0\Source\portable\RVDS\ARM_CM3;.\FreeRTOSv9.0.0;.\Tasks\UserTasks;.\System;.\System\delay;.\System\sys;.\System\usart;.\Hardware\LED;.\Software;.\Hardware\RFID
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\stm32f1xx_demo.sct
  group User
    ./User/: main.c
  group Tasks
    ./Tasks/UserTasks/: user_tasks.c usart_task.c led_task.c
  group System
    ./System/: stm32f10x_it.c
    ./System/usart/: usart.c
    ./System/sys/: sys.c
    ./System/delay/: delay.c
  group Startup
    ./Startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOSv9.0.0/Source
    ./FreeRTOSv9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv9.0.0/Port
    ./FreeRTOSv9.0.0/Source/portable/MemMang/: heap_4.c
    ./FreeRTOSv9.0.0/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOSv9.0.0/: FreeRTOSConfig.h
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/RFID/: rfid.c
    ./Hardware/MOTOR/: motor.c
  group Software
    ./Software/: usart_loop_queue.c message_manager.c led_function.c
